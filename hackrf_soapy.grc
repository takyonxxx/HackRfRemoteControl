options:
  parameters:
    generate_options: qt_gui
    id: hackrf_soapy
    output_language: python
    title: HackRf
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: fm_demod
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 480e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: hackrf_source
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    dev_args: driver=hackrf
    gain: '40'
    samp_rate: samp_rate
    type: fc32
    vga: '40'
  states: {}
- name: low_pass_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: 150e3
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: multiply_const
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '24'
    type: ccc
  states: {}

connections:
- [fm_demod, '0', multiply_const, '0']
- [hackrf_source, '0', low_pass_filter, '0']
- [low_pass_filter, '0', rational_resampler, '0']
- [multiply_const, '0', audio_sink, '0']
- [rational_resampler, '0', fm_demod, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
