options:
  parameters:
    generate_options: qt_gui
    id: hackrf_osmosdr_low
    output_language: python
    title: HackRf
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.75'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 80e6
    step: '0.1'
    stop: 108e6
    value: 100e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: 'int(sample_rate/channel_width) '
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 480e3
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alias: Spectrum
    average: '0.05'
    bw: sample_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: low_pass_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: channel_width
    decim: '6'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: channel_width/12
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '60'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(sample_rate*decimation / 1e6)
    interp: int(sample_rate/ 1e6)
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink, '0']
- [low_pass_filter, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', freq_sink, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
